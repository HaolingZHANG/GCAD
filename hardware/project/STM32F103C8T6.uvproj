# Keil uVision project STM32F103C8T6.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103C8T6 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\user;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xff00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c stm32f10x_it.c serial.c sys_init.c delay.c infrared.c dataprotocol.c pitchRollYaw.c iic1_leftleg.c iic2_rightleg.c iic3_body.c iic4_foot.c prdSensorDeal.c motionsta.c xyz_algo.c
  group startup
    ../startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c
  group eMPL
    ../eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
